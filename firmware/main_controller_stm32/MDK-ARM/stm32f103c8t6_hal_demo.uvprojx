# Keil uVision project stm32f103c8t6_hal_demo.uvprojx, settings and files
target stm32f103c8t6_hal_demo (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103c8t6_hal_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../ktlib;../ktlib/kt_debug;../ktlib/kt_log;../ktlib/kt_protocol;../ktlib/kt_port;../ktlib/kt_components;../ktlib/kt_cmd
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ktlib/ktlib_debug
    ../ktlib/kt_debug/: kt_debug.c
  group ktlib/ktlib_protocol
    ../ktlib/kt_protocol/: kt_debug_protocol.c kt_protocol.c
  group ktlib/ktlib_components
    ../ktlib/kt_components/: kt_ringbuf.c
  group ktlib/ktlib_cmd
    ../ktlib/kt_cmd/: kt_cmd.c
  group ktlib/ktlib_port
    ../ktlib/kt_port/: kt_port_uart.c kt_port_gpio.c
  group ktlib/ktlib_log
    ../ktlib/kt_log/: kt_log.c
software components: CMSIS:CORE 5.6.0
